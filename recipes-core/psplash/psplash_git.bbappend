FILESEXTRAPATHS_prepend_poky := "${THISDIR}/files:"

#test lollo
#FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
#SRC_URI_append = "file://0001-sfondo-bianco-patch"
#SRC_URI_append = "file://0001-sfondo-bianco-patch;patchdir=${WORKDIR}/git"
