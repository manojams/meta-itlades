inherit setuptools3
require python-dependency-injector.inc
