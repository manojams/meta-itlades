
RDEPENDS_${PN} += "\
                ital-wvdialChat \
                ital-wvdial-service \
                "
