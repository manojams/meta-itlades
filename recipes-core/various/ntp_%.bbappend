FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
INITSCRIPT_NAME = "ntpd"
INITSCRIPT_PARAMS = "disable"