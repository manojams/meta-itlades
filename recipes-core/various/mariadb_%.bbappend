
FILES_${PN}-server += "\
      ${bindir}/mysqld_safe_helper \
      "

#SRC_URI += "file://my.patch;patchdir=${WORKDIR}"

#FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
#SRC_URI += "file://my.patch"
