
RDEPENDS_${PN} += "\
                ital-wvdial-service \
                "
