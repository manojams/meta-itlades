SUMMARY = "Italdes python supervisor"
LICENSE = "CLOSED"

RDEPENDS_${PN} = "\
    packagegroup-qt5-qtcreator-debug \
    fw-nandautosize \
    u-boot-eng-fw-utils \
    engicam-mtd-script \
    ital-cert-https \
    mtd-utils \
    imx-kobs \
    mtd-utils-ubifs \
    tslib \
    evtest \
    tslib-conf \
    tslib-tests \
    tslib-calibrate \
    "
