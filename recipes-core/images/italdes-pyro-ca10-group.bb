SUMMARY = "Italdes python supervisor"
LICENSE = "CLOSED"

RDEPENDS_${PN} = "\
    ital-confignetwork-git \
    ital-cert-knox \
    ital-cert-ssh-guardian \
    ital-conf-vpn \
    ital-cert-https \
    ca10-CommManager \
    ital-main-app-git \
    ital-media-audio \
    ital-media-video \
    ital-main-app-git \
    ital-config-model-ca10-test \
    ital-config-model-ca10-prod \    
    "
